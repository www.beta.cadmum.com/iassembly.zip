# Autodesk Inventor assembly: Single Knob Drawer
## iProperties
Created: 2006-01
Part Number: Single Knob Drawer
Document SubType Name: Assembly
Designer: Demir Ali
Author: Demir Ali
