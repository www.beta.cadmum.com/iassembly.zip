# Autodesk Inventor assembly: Simple Single Knob Drawer
## iProperties
Created: 2006-01
Part Number: Simple Single Knob Drawer
Document SubType Name: Assembly
Designer: Demir Ali
Author: Demir Ali
