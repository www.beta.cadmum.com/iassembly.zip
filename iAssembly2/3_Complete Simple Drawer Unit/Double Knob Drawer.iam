# Autodesk Inventor assembly: Double Knob Drawer
## iProperties
Created: 2006-05
Part Number: Double Knob Drawer
Document SubType Name: Assembly
Designer: Torbjörn
Author: Torbjörn
