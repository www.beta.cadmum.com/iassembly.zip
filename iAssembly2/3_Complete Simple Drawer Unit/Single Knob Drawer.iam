# Autodesk Inventor assembly: Single Knob Drawer
## iProperties
Created: 2006-05
Part Number: Single Knob Drawer
Document SubType Name: Assembly
Designer: Torbjörn
Author: Torbjörn
